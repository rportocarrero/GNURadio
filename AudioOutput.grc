options:
  parameters:
    generate_options: qt_gui
    id: AudioOutput
    output_language: python
    title: Not titled yet
  states: {state: disabled}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}

connections:
- [analog_sig_source_x_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
